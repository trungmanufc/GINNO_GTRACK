<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\W25Q16_F401.ewp</path>
  </project>
  <batchBuild />
</workspace>
